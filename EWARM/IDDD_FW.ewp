# IAR project IDDD_FW.ewp, settings and files
configuration IDDD_FW (ARM, debug)
  General.OGChipSelectEditMenu: STM32L051R8 ST STM32L051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U031xx
  ICCARM.CCIncludePath2: $TOOLKIT_DIR/inc/c; ../Core/Inc; ../Drivers/STM32U0xx_HAL_Driver/Inc; ../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U0xx/Include; ../Drivers/CMSIS/Include; ../FreeRTOS; ../FreeRTOS/include; ../FreeRTOS/portable/IAR/ARM_CM0; ../FreeRTOS/portable/MemMang; ../USER; ../USER/L0_Common; ../USER/L1_Drive; ../USER/L1_Drive/L1_00_HW; ../USER/L1_Drive/L1_01_Component; ../USER/L1_Drive/L1_01_Component/L1_01_00_EEPROM; ../USER/L1_Drive/L1_01_Component/L1_01_01_IDDD_TRF_Drv; ../USER/L1_Drive/L1_01_Component/L1_01_02_IDDD_BAT_ADC_Drv; ../USER/L1_Drive/L1_01_Component/L1_01_03_BoTnLE525BLE_Drv; ../USER/L1_Drive/L1_02_Module; ../USER/L1_Drive/L1_02_Module/L1_02_00_FreeRTOS_Plus_CLI; ../USER/L1_Drive/L1_02_Module/L1_02_01_hsData_Block_Access_Module; ../USER/L1_Drive/L1_02_Module/L1_02_02_Key_Module; ../USER/L2_Interface; ../USER/L2_Interface/L2_00_IDDD_DBA_Interface; ../USER/L2_Interface/L2_01_IDDD_RunCMD_Interface; ../USER/L2_Interface/L2_03_IDDD_Display_Interface; ../USER/L3_Application; ../USER/L3_Application/L3_00_hsDEBUG_UART_CLI_App; ../USER/L3_Application/L3_01_IDDD_RunCommand_app; ../USER/L3_Application/L3_02_IDDD_MainCommunication_App; ../USER/L3_Application/L3_03_IDDD_Display_App
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc; ../Drivers/STM32U0xx_HAL_Driver/Inc; ../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U0xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include/; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../Middlewares/Third_Party/CMSIS/RTOS2/Include/; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/
  OBJCOPY.OOCOutputFile: IDDD_FW.bin
  ILINK.IlinkOutputFile: IDDD_FW.out
  ILINK.IlinkIcfFile: stm32u031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u031xx.s
  group Application/User/Core
    ../Core/Src/: freertos.c freertos_hooks.c main.c stm32u0xx_hal_msp.c stm32u0xx_hal_timebase_tim.c stm32u0xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u0xx.c
  group Drivers/STM32U0xx_HAL_Driver
    ../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal.c stm32u0xx_hal_adc.c stm32u0xx_hal_adc_ex.c stm32u0xx_hal_cortex.c stm32u0xx_hal_dac.c stm32u0xx_hal_dac_ex.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_exti.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_i2c.c stm32u0xx_hal_i2c_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c stm32u0xx_hal_uart.c stm32u0xx_hal_uart_ex.c stm32u0xx_ll_adc.c stm32u0xx_ll_i2c.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/IAR
    ../FreeRTOS/portable/IAR/ARM_CM0/: port.c portasm.s
  group FreeRTOS/MemMang
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group USER
    ../USER/: User_Main.c
  group USER/L0_Common
    ../USER/L0_Common/: hsCommon_Utill.c hsDebug_MSG.c hsGlobalErrorHandle.c Rework_PP_Drv.c
  group USER/L1_Drive/L1_00_HW
    ../USER/L1_Drive/L1_00_HW/: Common_HAL.c
  group USER/L1_Drive/L1_01_Component/L1_01_00_EEPROM
    ../USER/L1_Drive/L1_01_Component/L1_01_00_EEPROM/: hsEEPROM_Drv.c port_hsEEPROM_Drv.c
  group USER/L1_Drive/L1_01_Component/L1_01_01_IDDD_TRF
    ../USER/L1_Drive/L1_01_Component/L1_01_01_IDDD_TRF_Drv/: IDDD_ADC_SCAN_Drv.c IDDD_LED_CTRL_Drv.c IDDD_TRF_Timer_CTRL.c
  group USER/L1_Drive/L1_01_Component/L1_01_02_IDDD_BAT_ACD
    ../USER/L1_Drive/L1_01_Component/L1_01_02_IDDD_BAT_ADC_Drv/: IDDD_BAT_ADC_Drv.c
  group USER/L1_Drive/L1_01_Component/L1_01_03_BoTnLE525_Drv
    ../USER/L1_Drive/L1_01_Component/L1_01_03_BoTnLE525BLE_Drv/: BoTnLE525BLE_Drv.c BoTnLE525BLE_Port.c
  group USER/L1_Drive/L1_02_Module/L1_02_00_FreeRTOS_Plus_CLI
    ../USER/L1_Drive/L1_02_Module/L1_02_00_FreeRTOS_Plus_CLI/: FreeRTOS_CLI.c
  group USER/L1_Drive/L1_02_Module/L1_02_01_hsDBA_Module
    ../USER/L1_Drive/L1_02_Module/L1_02_01_hsData_Block_Access_Module/: hsDataBlockAccess_Module.c
  group USER/L1_Drive/L1_02_Module/L1_02_02_Key_Module
    ../USER/L1_Drive/L1_02_Module/L1_02_02_Key_Module/: hsKey_Module.c
  group USER/L2_Interface/L2_00_IDDD_DBA_Interface
    ../USER/L2_Interface/L2_00_IDDD_DBA_Interface/: IDDD_DBA_RAM_Interface.c IDDD_DBA_ROM_Interface.c
  group USER/L2_Interface/L2_01_IDDD_RunCommand_Interface
    ../USER/L2_Interface/L2_01_IDDD_RunCMD_Interface/: IDDD_RunCmd_TRF_Interface.c IDDD_RunCommand_Interface.c
  group USER/L2_Interface/L2_03_IDDD_Display_Interface
    ../USER/L2_Interface/L2_03_IDDD_Display_Interface/: Display_Interface.c
  group USER/L3_Application/L3_00_hsDEBUG_USART_CLI_App
    ../USER/L3_Application/L3_00_hsDEBUG_UART_CLI_App/: hsCLI_Command.c hsDEBUG_UART_CLI_App.c port_hsDEBUG_UART_CLI_App.c
  group USER/L3_Application/L3_01_IDDD_RunCommand_App
    ../USER/L3_Application/L3_01_IDDD_RunCommand_app/: IDDD_RunCommand_App.c
  group USER/L3_Application/L3_02_IDDD_Main_Communication_App
    ../USER/L3_Application/L3_02_IDDD_MainCommunication_App/: Main_Communication_App.c
  group USER/L3_Application/L3_03_IDDD_Display_App
    ../USER/L3_Application/L3_03_IDDD_Display_App/: Display_Application.c
